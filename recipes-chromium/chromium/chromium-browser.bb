require chromium-browser-${MACHINE}.bb
