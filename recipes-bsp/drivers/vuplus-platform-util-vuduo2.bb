require vuplus-platform-util.inc

COMPATIBLE_MACHINE = "^(vuduo2)$"

SRCDATE = "20170522"
SRCDATE_PR = "r0"

SRC_URI[md5sum] = "827ae1dae321402c8ef576b0b1385656"
SRC_URI[sha256sum] = "307d8ed020d20c1786cc16292a5b860510904f02baa49798aefe11dc3211981a"
